Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-09-29T14:38:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 29 14:38:09 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{769D49D3-48D9-45BD-965A-DD4E16367200}\ifc * Database version: 5507 * Database creation date: Wed Sep 29 14:38:08 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 29 14:38:08 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 29 14:38:08 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 27121252_CN_9117220_CS1212-1C_EDST, 09117220_CN_CS1212-1C_EDST:27121252_CN_9117220_CS1212-1C_EDST:206937
In: Level 1
Type - Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 27121252_CN_9117220_CS1212-1C_EDST
Pset_ManufacturerTypeInformation - Manufacturer: Miele
